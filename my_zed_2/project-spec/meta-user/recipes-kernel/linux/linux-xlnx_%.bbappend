SRC_URI += "file://bsp.cfg \
            file://user_2024-03-04-17-37-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
